Commit message: (WIP) keypoint data generation

File: data_generation/assets/mjc.urdf (robot description, URDF)
Before this commit: robot MJC, 1 links, 0 joints
Links:
- link base: mass 1115 -> 111.5
